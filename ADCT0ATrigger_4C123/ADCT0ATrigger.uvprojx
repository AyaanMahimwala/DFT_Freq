# Keil uVision project ADCT0ATrigger.uvprojx, settings and files
target ADCT0ATrigger (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADCT0ATrigger
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ADCTestmain.c Speaker.h Speaker.c DAC.h DAC.c
    ../inc/: PLL.c ADCT0ATrigger.c LaunchPad.c Texas.c Texas.h Timer1A.c Timer1A.h
software components: CMSIS:CORE 5.0.2
